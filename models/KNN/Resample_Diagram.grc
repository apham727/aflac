<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>file</key><value>output_filepath</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>input_filepath</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frac_dem</value></param>
<param><key>label</key><value>frac_dem</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frac_num</value></param>
<param><key>label</key><value>frac_num</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>input_filepath</value></param>
<param><key>label</key><value>input_filepath</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>//home/duncan/Documents/ML_Project/filtered_files_short/0a2a5c05.wav</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_filepath</value></param>
<param><key>label</key><value>output_filepath</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>//home/duncan/Documents/ML_Project/filtered_files_short_resampled/0a2a5c05.wav</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>frac_num</value></param>
<param><key>interp</key><value>frac_dem</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
